# Keil uVision project Code.uvprojx, settings and files
target DesignStart (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Code
  AfterMake: fromelf -cvf code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf code.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Software
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: cmdsasm.s main.c vga_api.c vga_api.h picture.h
